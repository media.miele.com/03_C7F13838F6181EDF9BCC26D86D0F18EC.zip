Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 06560bae-bf39-40d7-8a87-b9a770d8f792, NumberOfSaves: 1]
File name: 0001
Time: 2024-09-04T13:13:53+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11966870_SOM_PDR910EL_SST:52910012_SOM_11966870_PDR910EL_SST, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass Black, z_Miele_Design_CLST, z_Miele_Design_Stainless_Steel, <Unnamed>, z_Miele_Design_Glass, z_Miele_Connection_Electric, Default, z_Miele_Connection_ExhaustAir, z_Miele_Design_Iron_Grey
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 700 mm; Height: 1020 mm; Depth: 763 mm
Pset_BuildingElementProxyCommon - Reference: 52910012_SOM_11966870_PDR910EL_SST; sets with these values: 2
